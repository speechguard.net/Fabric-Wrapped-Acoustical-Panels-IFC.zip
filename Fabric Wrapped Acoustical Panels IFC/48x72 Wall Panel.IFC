Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: 48x72 Wall Panel.IFC
Time: 2025-04-18T12:41:52
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: 48x72 Wall Panel
In: Default Storey
Material: Steel
